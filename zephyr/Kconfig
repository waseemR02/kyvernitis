## zephyr/Kconfig
```kconfig
config KYVERNITIS
	bool "Enable kyvernitis"
	help
	  This option enables kyvernitis as a Zephyr module.
```
